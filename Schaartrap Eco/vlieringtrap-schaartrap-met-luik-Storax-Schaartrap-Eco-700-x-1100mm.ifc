Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 1be10344-6907-455c-a31f-9a5353a6a7e6.ifc
Time: 2026-08-11T15:45:44
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcStair, vlieringtrap schaartrap met luik Storax - Schaartrap Eco 700 x 1100mm
In: Bouwlaag
Material: aluminium
Pset_Data - WUID: AgAAAMMBnMAGAAAARewCAAWxXwAAPHsBAHQGAAB37AIAw-sCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIAcusCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAJFYAAAFabkAAGQwAADGpwAAo60AAL8lAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAMMBnMAGAAAARewCAAWxXwAAPHsBAHQGAAB37AIAw-sCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIAcusCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAJFYAAAFabkAAGQwAADGpwAAo60AAL8lAAAAAA)); STABU2: 32.32.11; lengte: 1080 mm; inbouwhoogte: 240 mm; inbouwlengte: 1100 mm; luchtdoorlatendheid klasse: 4; U-waarde: 0,77 w/m²·k; breedte: 680 mm; max. belasting: 150 kg; NAA.K.T: samengesteld_product_generiek; bediening: handmatig; theoretische levensduur: 50; serie: Schaartrap Eco; inbouwbreedte: 700 mm; merk: Storax; beweegbaar: True; omranding: hout; luik: hout; trap: schaarladder Storax - Schaarladder 330mm
